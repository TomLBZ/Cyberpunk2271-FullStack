# Keil uVision project Cyberpunk2271_EmbeddedC.uvprojx, settings and files
target Robot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Cyberpunk2271_EmbeddedC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Main
    ./: Main.c Main.h Macros.h
  group GPIO
    ./: GPIO.h GPIO.c
  group Init
    ./: Init.h Init.c
  group Threading
    ./: Threads.h Threads.c
  group OnboardLED
    ./: OnboardLED.h OnboardLED.c
  group Definitions
    ./: PinDefinitions.h PinDefinitions.c ConstantDefinitions.h ConstantDefinitions.c
  group Music
    ./: Music.h Music.c
  group TPM
    ./: TPM.h TPM.c
  group PIT
    ./: PIT.h PIT.c
  group Chassis
    ./: Chassis.c Chassis.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 2.5.0
